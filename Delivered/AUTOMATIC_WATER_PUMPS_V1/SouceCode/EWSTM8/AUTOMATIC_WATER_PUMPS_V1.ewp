# IAR project AUTOMATIC_WATER_PUMPS_V1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCIncludePath2: ..\Drivers\inc; ..\Source
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: AUTOMATIC_WATER_PUMPS_V1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ../Source/: main.cpp stm8s_it.c
  group Drivers
    ../Drivers/src/: stm8s_clk.c stm8s_gpio.c
