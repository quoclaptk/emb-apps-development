<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>STM8S207R8T6_GPIO.ewp</path>
    </project>
    <batchBuild />
</workspace>