# IAR project STM8S207R8T6_GPIO.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCIncludePath2: ..\Driver\inc; ..\Source
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S207R8T6_GPIO.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Driver
    ../Driver/src/: stm8s_clk.c stm8s_gpio.c
  group Source
    ../Source/: main.c
