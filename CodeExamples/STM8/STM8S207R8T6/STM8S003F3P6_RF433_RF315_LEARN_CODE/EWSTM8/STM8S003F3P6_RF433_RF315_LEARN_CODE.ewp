# IAR project STM8S003F3P6_RF433_RF315_LEARN_CODE.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCIncludePath2: ..\Drivers\inc; ..\Libraries\RCSwitch; ..\Libraries\utility; ..\Source
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: STM8S003F3P6_RF433_RF315_LEARN_CODE.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group Drivers
    ../Drivers/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c
  group Libraries
    ../Libraries/RCSwitch/: RCSwitch.cpp
    ../Libraries/utility/: utility.cpp
  group Source
    ../Source/: main.cpp stm8s_it.c
