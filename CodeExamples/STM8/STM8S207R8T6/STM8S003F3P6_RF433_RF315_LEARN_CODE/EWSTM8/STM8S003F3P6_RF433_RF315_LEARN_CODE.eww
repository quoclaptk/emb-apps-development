<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\STM8S003F3P6_RF433_RF315_LEARN_CODE\EWSTM8\STM8S003F3P6_RF433_RF315_LEARN_CODE.ewp</path>
    </project>
    <batchBuild />
</workspace>
