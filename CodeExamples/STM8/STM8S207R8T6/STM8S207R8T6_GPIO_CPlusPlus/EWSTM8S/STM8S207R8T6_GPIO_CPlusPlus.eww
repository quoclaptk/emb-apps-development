<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM8S207R8T6_GPIO_CPlusPlus.ewp</path>
    </project>
    <batchBuild />
</workspace>
