# IAR project STM8S207R8T6_GPIO_CPlusPlus.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCIncludePath2: ..\Driver\inc; ..\Source; ..\Libraries\RCSwitch; ..\Libraries\utility
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: STM8S207R8T6_GPIO_CPlusPlus.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group Driver
    ../Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_tim4.c
  group Libraries/RCSwitch
    ../Libraries/RCSwitch/: RCSwitch.cpp
  group Libraries/utility
    ../Libraries/utility/: utility.cpp
  group Source
    ../Source/: main.cpp stm8s_it.c
